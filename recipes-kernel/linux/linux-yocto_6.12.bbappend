KBRANCH:nxp-ls1046 = "v6.12/standard/nxp-sdk-6.12/nxp-soc"

require linux-yocto-nxp-ls1046.inc
